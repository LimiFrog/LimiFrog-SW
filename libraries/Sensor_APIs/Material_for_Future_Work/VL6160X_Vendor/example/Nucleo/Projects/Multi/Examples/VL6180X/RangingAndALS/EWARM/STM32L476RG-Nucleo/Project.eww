<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32L476RG-Nucleo.ewp</path>
  </project>
  <batchBuild />
</workspace>
