# Keil uVision project NucleoL053RangingWithSatellites.uvprojx, settings and files
target NucleoL053RangingWithSatellites (ARM-ADS)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: NucleoL053RangingWithSatellites +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\..\Drivers\BSP\Components\vl6180x;..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-6180XA1
  asm include: ..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/User
    ../../Src/: stm32l0xx_it.c stm32l0xx_hal_msp.c main.c
    ../../../../../../../Drivers/BSP/Components/vl6180x/: vl6180x_api.c vl6180x_i2c.c
    ../../../../../../../Drivers/BSP/X-NUCLEO-6180XA1/: x-nucleo-6180xa1.c
  group Application/MDK-ARM
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l053xx.s
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_i2c.c stm32l0xx_hal_cortex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_i2c_ex.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
